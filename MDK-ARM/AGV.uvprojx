# Keil uVision project AGV.uvprojx, settings and files
target AGV (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: AGV
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;    ../Drivers/CMSIS/Include;    .\User\;    .\User\MPU6050\;    .\User\SSD1306\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c i2c.c gpio.c tim.c usart.c dma.c
    ./User/: control.c
    ./User/MPU6050/: MPU6050.c MPU6050_6Axis_MotionApps20.c
    ./User/SSD1306/: fonts.c ssd1306.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
software components: CMSIS:CORE 4.1.0
